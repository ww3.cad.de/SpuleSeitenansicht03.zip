# Autodesk Inventor part: Spule Seitenansicht03
## iProperties
Created: 2009-03
Part Number: Spule Seitenansicht03
Document SubType Name: Modeling
Designer: Neugebauer
Author: Neugebauer
